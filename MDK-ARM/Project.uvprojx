# Keil uVision project Project.uvprojx, settings and files
target STM32L4R5ZI_NUCLEO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L4R5ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R5xx,USE_FULL_LL_DRIVER
  c include: ../Inc;F:\stm32cube_repos\STM32Cube_FW_L4_V1.10.0\Drivers\CMSIS\Device\ST\STM32L4xx\Include;F:\stm32cube_repos\STM32Cube_FW_L4_V1.10.0\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\STM32L4R5ZI-Nucleo\Templates\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Example/User
    ../Src/: main.c stm32l4xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32l4r5xx.s
  group Drivers/STM32L4xx_LL_Driver
    F:/stm32cube_repos/STM32Cube_FW_L4_V1.10.0/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.0.2, Compiler:I/O:STDOUT 1.2.1
